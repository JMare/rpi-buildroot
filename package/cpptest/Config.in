## package/cpptest/Config.in
```kconfig
config BR2_PACKAGE_CPPTEST
    bool "cpptest"
    default y
    help
            cpptest component.
```
